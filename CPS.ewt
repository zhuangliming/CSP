<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <group>
      <name>Modbus</name>
      <group>
        <name>Functions</name>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\functions\mbfunccoils.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\functions\mbfuncdiag.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\functions\mbfuncdisc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\functions\mbfuncholding.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\functions\mbfuncinput.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\functions\mbfuncother.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\functions\mbutils.c</name>
        </file>
      </group>
      <group>
        <name>Port</name>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\port\portevent.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\port\portserial.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\port\porttimer.c</name>
        </file>
      </group>
      <group>
        <name>RTU</name>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\rtu\mbcrc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\rtu\mbrtu.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\Code\Application\Modbus\mb.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\Code\Application\csp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Code\Application\modbus_app.c</name>
    </file>
  </group>
  <group>
    <name>BSP</name>
    <group>
      <name>STM32F10x</name>
      <group>
        <name>Device</name>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Device\board.c</name>
        </file>
      </group>
      <group>
        <name>Libs</name>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\misc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_bkp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_can.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_cec.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_crc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_dac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_dbgmcu.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_dma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_exti.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_fsmc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_i2c.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_iwdg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_pwr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_rcc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_rtc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_sdio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_tim.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_usart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\STM32F10x\Libs\src\stm32f10x_wwdg.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\Code\BSP\STM32F10x\startup_stm32f10x_md.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\BSP\STM32F10x\stm32f10x_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\BSP\STM32F10x\system_stm32f10x.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>uCOS-II</name>
    <group>
      <name>Config</name>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Config\os_cfg.h</name>
      </file>
    </group>
    <group>
      <name>Device</name>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Device\os_device.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Device\os_object.c</name>
      </file>
    </group>
    <group>
      <name>Ports</name>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Ports\os_cpu_a.S</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Ports\os_cpu_c.c</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Source\os_core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Source\os_flag.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Source\os_mbox.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Source\os_mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Source\os_mutex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Source\os_q.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Source\os_sem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Source\os_task.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Source\os_time.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Source\os_tmr.c</name>
      </file>
    </group>
  </group>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
</project>


