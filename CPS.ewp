# IAR project CPS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: Code\Application; Code\uCOS-II\Config; Code\uCOS-II\Ports; Code\uCOS-II\Source; Code\uCOS-II\Device; Code\uCOS-II\App; Code\Application\Modbus\include; Code\Application\Modbus\port; Code\Application\Modbus\rtu; Code\BSP\STM32F10x\Libs\inc; Code\BSP\STM32F10x; Code\BSP\STM32F10x\Device
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group Application
    Code/Application/: csp.c modbus_app.c
  group Application/Modbus
    Code/Application/Modbus/: mb.c
  group Application/Modbus/Functions
    Code/Application/Modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Application/Modbus/Port
    Code/Application/Modbus/port/: portevent.c portserial.c porttimer.c
  group Application/Modbus/RTU
    Code/Application/Modbus/rtu/: mbcrc.c mbrtu.c
  group BSP/STM32F10x
    Code/BSP/STM32F10x/: startup_stm32f10x_md.s stm32f10x_it.c system_stm32f10x.c
  group BSP/STM32F10x/Device
    Code/BSP/STM32F10x/Device/: board.c
  group BSP/STM32F10x/Libs
    Code/BSP/STM32F10x/Libs/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uCOS-II/Config
    Code/uCOS-II/Config/: os_cfg.h
  group uCOS-II/Device
    Code/uCOS-II/Device/: os_device.c os_object.c
  group uCOS-II/Ports
    Code/uCOS-II/Ports/: os_cpu_a.S os_cpu_c.c
  group uCOS-II/Source
    Code/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
